## config/boards/shields/migpad/Kconfig.shield
```kconfig
# Copyright (c) 2020 Pete Johanson
# SPDX-License-Identifier: MIT

config SHIELD_MIGPAD
    def_bool $(shields_list_contains,migpad)
```
